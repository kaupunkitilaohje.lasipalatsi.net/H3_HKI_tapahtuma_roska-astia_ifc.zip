Properties of the parts of a building model (IFC2X3)

# File
Description: IFC 2x3 Building Model
Time: 2016-12-07T15:52:44
Author: Katajamäki, Jokke
Organization: WSP Finland
Made in: ASIFC - 2.5.4.645

# IfcProject
Description: SolidWorks IGES file using analytic representation for surfaces; LongName: H3_HKR_tapahtuma_roska-astia

# IfcSite, Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcFurnishingElement (18)
In: Site
Name | Description
4 x HKR-TAPAHTUMA ROSKA-ASTIA / LUUKKU | Kuumasinkitys+ sinkkifosfatointi + jauhemaalaus (tai vastaava yhdistelmä) väri RAL 6012 tai RAL 7021
HKR-TAPAHTUMA ROSKA-ASTIA / SOKKELI | RST, hionta grit 180
6 x HKR-TAPAHTUMA ROSKA-ASTIA / ULKOKUORI | Kuumasinkitys+ sinkkifosfatointi + jauhemaalaus (tai vastaava yhdistelmä) väri RAL 6012 tai RAL 7021
HKR-TAPAHTUMA ROSKA-ASTIA / SISÄSÄILIÖ | Kuumasinkitty teräs
HKR-TAPAHTUMA ROSKA-ASTIA / KAULUS | RST, hionta grit 180
2 x HKR-TAPAHTUMA ROSKA-ASTIA / KAHVA
3 x HKR-TAPAHTUMA ROSKA-ASTIA / KANSI | Kuumasinkitys+ sinkkifosfatointi + jauhemaalaus (tai vastaava yhdistelmä) väri RAL 6012 tai RAL 7021
